RPROVIDES_${PN} =+ " librtmp0"
